## config/boards/shields/cookies/Kconfig.defconfig
```kconfig
if SHIELD_COOKIES

config ZMK_KEYBOARD_NAME
    default "cookies"

config BT_DEVICE_NAME
    default ZMK_KEYBOARD_NAME

endif
```
